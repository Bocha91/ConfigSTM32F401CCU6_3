<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ConfigSTM32F401CCU6_3.ewp</path>
  </project>
  <batchBuild />
</workspace>
